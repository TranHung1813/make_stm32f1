# Keil uVision project LP_IO_V2_Bootloader.uvprojx, settings and files
target GD32F330 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LP_IO_V2_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F330,USE_STDPERIPH_DRIVER,GD32F3X0,MIN_CRC32_MINIMAL=1,DIGITAL_POT=0
  c include: .\stdlib\inc;..\..\port_fw\app_cli;..\..\port_fw\app_debug;..\..\port_fw\board_hw\include;..\..\port_fw\host_data_layer;..\..\port_fw\lpf;..\..\port_fw\lwrb\lwrb\src\include;..\..\port_fw\min\include;..\..\port_fw\ota_update;..\..\port_fw\pot;..\..\port_hw\gd32f330;..\..\port_fw\SEGGER_RTT_V762b\Config;..\..\port_fw\SEGGER_RTT_V762b\RTT;..\Projects;.\stdlib\include;.\RTE\_App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ./: gd32f3x0_it.c systick.c
  group stdlib
    ./: main.c startup_gd32f3x0.s
    ./stdlib/src/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_fmc.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c system_gd32f3x0.c
  group port/app_cli
    ../../port_fw/app_cli/: app_cli.c app_cli.h app_shell.c app_shell.h
  group port/app_debug
    ../../port_fw/app_debug/: app_debug.c app_debug.h
  group port/board_hw
    ../../port_fw/board_hw/include/: board_hw.h
    ../../port_hw/gd32f330_bootloader/: board_hw.c
  group port/host_data_layer
    ../../port_fw/host_data_layer/: host_data_layer.h
    ../../port_hw/gd32f330_bootloader/: host_data_layer.c
  group port/lpf
    ../../port_fw/lpf/: lpf.c lpf.h
  group port/min
    ../../port_fw/min/: min.c
    ../../port_fw/min/include/: min.h min_id.h
  group port/lwrb
    ../../port_fw/lwrb/lwrb/src/lwrb/: lwrb.c
    ../../port_fw/lwrb/lwrb/src/include/lwrb/: lwrb.h
  group port/pot
    ../../port_fw/pot/: pt2257.c pt2257.h
  group port/SEGGER_RTT
    ../../port_fw/SEGGER_RTT_V762b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../port_fw/SEGGER_RTT_V762b/Config/: SEGGER_RTT_Conf.h
  group port/version_ctrl
    ../../port_hw/gd32f330/: version_control.h
  group port/ota_update
    ../../port_fw/ota_update/: flash_if.c flash_if.h ota_update.c ota_update.h
software components: CMSIS:CORE 5.5.0
