# Keil uVision project MCU_Monitor.uvprojx, settings and files
target MCU_Monitor (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: MCU_Monitor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,MIN_CRC32_MINIMAL=1
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../port_fw/app_cli;../../../port_fw/app_debug;../../../port_fw/host_data_layer;../../../port_fw/lpf;../../../port_fw/lwrb/lwrb/src/include/;../../../port_fw/min/include;../../../port_fw/ota_update;../../../port_fw/SEGGER_RTT_V762b/RTT;../../../port_fw/SEGGER_RTT_V762b/Config;../../../port_hw/monitor;../../../port_fw/lwrb/lwrb/src/include/lwrb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_usart.c stm32f1xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group app/app_debug
    ../../../port_fw/app_debug/: app_debug.c app_debug.h
  group board_hw
    ../../../port_hw/monitor/: board_hw.c board_hw.h
  group port/host_data_layer
    ../../../port_fw/host_data_layer/: host_data_layer.c host_data_layer.h
  group port/lpf
    ../../../port_fw/lpf/: lpf.c lpf.h
  group port/min
    ../../../port_fw/min/: min.c
    ../../../port_fw/min/include/: min.h min_id.h
  group port/lwrb
    ../../../port_fw/lwrb/lwrb/src/lwrb/: lwrb.c
    ../../../port_fw/lwrb/lwrb/src/include/lwrb/: lwrb.h
  group port/SEGGER_RTT
    ../../../port_fw/SEGGER_RTT_V762b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../../../port_fw/SEGGER_RTT_V762b/Config/: SEGGER_RTT_Conf.h
  group port/version_ctrl
    ../../../port_hw/monitor/: version_control.h
  group port/ota_update
    ../../../port_hw/monitor/: ota_update.h
software components: CMSIS:CORE 4.3.0
