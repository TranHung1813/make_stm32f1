# Keil uVision project BYT_RadioNet_IO_V2.uvprojx, settings and files
target BYT_RadioNet_IO_V2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L010C6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: BYT_Radionet_IO_V2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L010x6,MIN_CRC32_MINIMAL=1,USE_HAL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\..\port_fw\app_cli;..\..\port_fw\app_debug;..\..\port_fw\board_hw\include;..\..\port_fw\lpf;..\..\port_fw\lwrb\lwrb\src\include;..\..\port_fw\min\include;..\..\port_fw\ota_update;..\..\port_fw\pot;..\..\port_fw\SEGGER_RTT_V762b\RTT;..\..\port_fw\SEGGER_RTT_V762b\Config;..\..\port_hw\stm32;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;..\..\port_fw\host_data_layer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l010x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c iwdg.c usart.c rtc.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_usart.c stm32l0xx_ll_rtc.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group port/min
    ../../port_fw/min/: min.c
    ../../port_fw/min/include/: min.h min_id.h
  group port/app_cli
    ../../port_fw/app_cli/: app_cli.c app_cli.h app_shell.c app_shell.h
  group port/lpf
    ../../port_fw/lpf/: lpf.c lpf.h
  group port/lwrb
    ../../port_fw/lwrb/lwrb/src/lwrb/: lwrb.c
    ../../port_fw/lwrb/lwrb/src/include/lwrb/: lwrb.h
  group port/app_debug
    ../../port_fw/app_debug/: app_debug.c app_debug.h
  group port/SeggerRTT
    ../../port_fw/SEGGER_RTT_V762b/Config/: SEGGER_RTT_Conf.h
    ../../port_fw/SEGGER_RTT_V762b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
  group port/board_hw
    ../../port_fw/board_hw/include/: board_hw.h
    ../../port_hw/stm32/board_hw/: board_hw.c
  group host_data_layer
    ../../port_fw/host_data_layer/: host_data_layer.c host_data_layer.h
  group version_control
    ../../port_hw/stm32/: version_control.h
  group pot
    ../../port_fw/pot/: pt2257.c pt2257.h
software components: CMSIS:CORE 4.3.0
